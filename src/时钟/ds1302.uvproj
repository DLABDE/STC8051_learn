# Keil uVision project ds1302.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: ds1302 +hex
  c flags: Optimize=7 SizeSpeed=1
  group Source Group 1
    ./: ds1302.c
